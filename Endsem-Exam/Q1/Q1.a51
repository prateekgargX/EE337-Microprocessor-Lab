ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAT_ADD
HERE: SJMP HERE

ORG 130H
MAT_ADD:
MOV A,30H
MOV B,A
MUL AB
MOV R4,A
MOV B,A

MOV R0,#31H
MOV A,#31H
ADD A,R4
MOV R1,A

LOOP:
	MOV A,@R0
	ADD A,@R1
	MOV R2,A
	MOV A,R1
	ADD A,R4
	MOV R1,A
	MOV A,R2
	MOV @R1,A
	MOV A,R1
	SUBB A,R4
	MOV R1,A
	INC R0
	INC R1
	DJNZ B,LOOP
	
RET

END